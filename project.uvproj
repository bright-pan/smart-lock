# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  c flags: wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x;Libraries/STM32F10x_StdPeriph_Driver/inc;RT-Thread/components/CMSIS/Include;RT-Thread/components/finsh;.\RT-Thread\libcpu;RT-Thread/libcpu/arm/common;RT-Thread/libcpu/arm/cortex-m3;.\RT-Thread\components\drivers\include;.\RT-Thread\components\dfs\include;.\RT-Thread\components\dfs\filesystems\elmfat;.\RT-Thread\components\drivers\include\drivers;.\RT-Thread\include;.\RT-Thread\components\libc\newlib;.\RT-Thread\components\libc\minilibc;.\RT-Thread\components\dfs\filesystems\devfs;.\RT-Thread\components\libc\minilibc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Application
    ./: local.c alarm.c gprs.c application.c startup.c board.c gsm_usart.c sdcard.c cpuusage.c photo.c mms_dev.c gsm.c untils.c mms.c battery.c
    ./RT-Thread/components/drivers/src/: dataqueue.c
  group Kernel
    RT-Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    RT-Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    RT-Thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FileSystem
    ./RT-Thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./RT-Thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group Zmodem
    ./RT-Thread/components/utilities/zmodem/: rz.c sz.c zcore.c zdevice.c zstart.c
  group Device_drive
    ./: spicamera.c sms.c sst25v16.c stm32f10x_it.c gpio_pin.c rfid_uart.c gpio_adc.c spibus.c usart.c rtc.c gpio.c gpio_pwm.c gpio_exti.c boardinfo.c camera_uart.c
    ./RT-Thread/components/drivers/spi/: spi_core.c spi_dev.c
    ./RT-Thread/components/drivers/src/: pipe.c ringbuffer.c completion.c
    ./RT-Thread/components/drivers/serial/: serial.c
  group Test
    ./: filetest.c testprintf.c
